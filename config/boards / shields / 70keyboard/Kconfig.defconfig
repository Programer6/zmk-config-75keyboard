## config/boards / shields / 70keyboard/Kconfig.shield
```kconfig
config SHIELD_70KEYBOARD
    def_bool $(shields_list_contains, custom_70keyboard)
```
